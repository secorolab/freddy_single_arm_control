Commit message: updating mass and inertia of bracelet link for stability

File: urdf/Kinova_1.urdf (robot description, URDF)
Before this commit: robot GEN3_URDF_V12, 10 links, 9 joints
Links:
- link Bracelet_Link: mass 0.5006 -> 0.7
